# Keil uVision project SRC.uvprojx, settings and files
target SRC (6160000::V6.16::ARMCLANG)
  device: STM32F411RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: SRC +hex
  BeforeMake: pwsh.exe -NoProfile -ExecutionPolicy Bypass -File ".\generate_gbk_ui_text.ps1" -InputPath "..\Core\Src\ui_text.cpp" -OutputPath ".\Generated\ui_text_gbk.cpp"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F411xE
  c misc: -fno-exceptions
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/User/Core
    ../Core/Src/: main.cpp basic.c rtc.c audio.c flash.c key.c lcd.c power.c rng.c app.cpp ui.cpp ui_sound.cpp save.cpp snake_game.cpp competitive_snake_game.cpp gobang_ai.cpp gobang_game.cpp game.cpp game_2048_rules.cpp game_2048.cpp flappy_bird_game.cpp flappy_bird_rules.cpp tetris_rules.cpp tetris_game.cpp minesweeper_rules.cpp minesweeper_game.cpp maze_rules.cpp maze_game.cpp layer_elimination_rules.cpp layer_elimination_game.cpp
    Generated/: ui_text_gbk.cpp
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/: startup_stm32f411xe.s system_stm32f4xx.c
software components: CMSIS:CORE 6.1.0
